RPROVIDES_${PN} += "network-configuration"
