FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Add-check-for-existence-of-old-file-to-renameat.patch"
