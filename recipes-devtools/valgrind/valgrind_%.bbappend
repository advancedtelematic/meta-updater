FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

# from https://bugs.kde.org/show_bug.cgi?id=344802 (John Reiser)
SRC_URI += "file://bug344802-unhandled-0xec510f1e.patch"
