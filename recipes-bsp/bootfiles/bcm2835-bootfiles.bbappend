RDEPENDS_${PN} += " u-boot-otascript"
