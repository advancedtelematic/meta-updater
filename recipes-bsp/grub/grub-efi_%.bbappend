
GRUB_BUILDIN += "configfile"
