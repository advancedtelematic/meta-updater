RDEPENDS_${PN}_append_sota += " u-boot-otascript"
