# null machine it's here to make bitbake happy when SOTA_MACHINE is undefined
