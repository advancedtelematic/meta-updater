FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append = "file://0001-Compare-c-string-with-NULL-instead-of-a-literal.patch"
