pkg_postinst_${PN} () {
}
