CFLAGS_append = " -fPIC"
