SYSROOT_DIRS += "${sysconfdir}"
