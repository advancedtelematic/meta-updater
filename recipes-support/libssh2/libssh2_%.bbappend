# meta-oe/recipes-support/libssh2
BBCLASSEXTEND_append_sota = " native"
