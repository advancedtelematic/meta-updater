ALTERNATIVE_${PN} += "bc"
